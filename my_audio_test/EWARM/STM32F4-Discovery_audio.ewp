# IAR project STM32F4-Discovery_audio.ewp, settings and files
configuration Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; STM32F40_41xxx; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\; ..\..\Libraries\CMSIS\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc; ..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\Utilities\STM32F4-Discovery
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F4-Discovery_audio.hex
  ILINK.IlinkOutputFile: STM32F4-Discovery_Demo.out
  ILINK.IlinkIcfFile: stm32f40x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../Utilities/STM32F4-Discovery/: libPDMFilter_IAR.a pdm_filter.h
    ../: waverecorder.h
  group EWARM
    ../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32F4_Discovery
    ../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_audio_codec.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group User
    ../: main.c stm32f4xx_it.c system_stm32f4xx.c waverecorder.c
